Commit message: Add files via upload

File: simple_gripper_2.urdf (robot description, URDF)
Before this commit: robot simple_gripper, 7 links, 5 joints
Links:
- removed link middle_finger
